# Keil uVision project 温度-时钟3.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 温度-时钟3 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main3.c 时钟3.c 温度3.c
